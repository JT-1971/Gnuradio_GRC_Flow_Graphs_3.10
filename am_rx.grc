options:
  parameters:
    author: DG7LAN
    generate_options: qt_gui
    id: AM_Receiver
    output_language: python
    title: AndyCeiver
  states: {}

blocks:
- name: filter_lp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '8'
    value: '6'
  states: {}
- name: lo_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '5800'
    step: '5'
    stop: '12000'
    value: '9210'
  states: {}
- name: rx_audio_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: taps_rx
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '12000'
    gain: '1.5'
    samp_rate: samp_rate/10
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '5'
    stop: '40000'
    value: '20000'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: 200e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tune_freq*-1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rx_audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps_rx
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: filter_lp*1000
    gain: '1'
    interp: '1'
    samp_rate: samp_rate/10
    type: interp_fir_filter_ccf
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '24'
    dc_offset_mode0: '1'
    freq0: lo_freq*1000
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '50'
    fc: lo_freq*1000-tune_freq
    fftsize: '2048'
    name: '"IF"'
    plotconst: 'False'
    plottime: 'False'
    rate: '5'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/12
    fc: lo_freq*1000-tune_freq
    fftsize: '1024'
    name: '"RF"'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_agc3_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_agc3_xx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
