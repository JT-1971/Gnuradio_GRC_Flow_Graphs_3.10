options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: HackRFOne_NFM
    output_language: python
    title: Receptor de NFM Estereo
  states: {}

blocks:
- name: Audio_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Volumen
    start: '0'
    step: '2.5e-2'
    stop: '50'
    value: '25'
    widget: dial
  states: {}
- name: BB_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: BB Gain
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
    widget: counter
  states: {}
- name: Bandwidth
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,2,1,1
    label: bandwidth
    label0: Auto
    label1: 1,75 MHz
    label2: 20 MHz
    num_opts: '3'
    option0: '0'
    option1: 1.75e6
    option2: 20e6
    type: real
    value: '0'
  states: {}
- name: FI_BWD
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    start: 10e3
    step: 5e3
    stop: 50E3
    value: 25e3
    widget: counter
  states: {}
- name: FI_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: FI Gain
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
    widget: counter
  states: {}
- name: RF_Gain
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,2,1,1
    label: RF Gain (13 dB)
    'true': '13'
    type: real
    value: '0'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: fi
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Sintonia [MHz]
    start: '100'
    step: '0.005'
    stop: '1000'
    value: '435.1'
    widget: counter
  states: {}
- name: freq_sdr
  id: variable
  parameters:
    value: freq*1e6 - fi
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Offset Re
    start: '-0.05'
    step: '1e-3'
    stop: '0.05'
    value: '-29e-3'
    widget: counter
  states: {}
- name: offset_Im
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Offset Im
    start: '-0.05'
    step: '1e-3'
    stop: '0.05'
    value: '8e-3'
    widget: counter
  states: {}
- name: piloto_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: '240000'
    type: complex_band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: '151'
    samp_rate: '19000'
    sym_rate: 19000/8
  states: {}
- name: rrc_taps_manchester
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation) / (2*math.pi*75000)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-20'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: complex(offset , offset_Im)
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_correctiq_1
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '0.001'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Audio_Gain
    type: float
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(1.0,240000,5e3,2e3)
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fi
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, FI_BWD/2, 20000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: BB_Gain
    bw0: Bandwidth
    freq0: freq_sdr
    gain0: RF_Gain
    gain_mode0: 'True'
    if_gain0: FI_Gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq_sdr
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab@0:0,0,5,5
    type: complex
    ymax: '-10'
    ymin: '-110'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate // decimation
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab@1:0,0,5,5
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: 240e3
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: qtgui_tab@2:0,0,5,5
    type: float
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,4,1,1
    label1: Señal
    min: '0'
    type: float
    update_time: '0.5'
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,5,5
    label0: Espectro de RF
    label1: Espectro Post FI
    label2: Espectro Post Dect
    num_tabs: '3'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate // decimation)
    interp: '240000'
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_correctiq_1, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_correctiq_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0, '0']
- [fir_filter_xxx_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_correctiq_0, '0']
- [osmosdr_source_0, '0', blocks_add_const_vxx_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_0_0, '0', fir_filter_xxx_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
