options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: LORA_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: I_MAX
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: I_MIN
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1090000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: LoRaRx_0
  id: LoRaRx
  parameters:
    BW: 125e3
    SF: '7'
    decimation: '1'
    detectionDecim: '1'
    detectorThreshold: '100'
    ignoreLowDataRateRequired: 'False'
    lowDataRate: 'False'
    samp_rate: 1e6
    syncwordNumber: '0x00'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    int_min: '-130'
    type: complex
  states: {}

connections:
- [LoRaRx_0, '0', blocks_null_sink_0, '0']
- [iio_pluto_source_0, '0', LoRaRx_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
