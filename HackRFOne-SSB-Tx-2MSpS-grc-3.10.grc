options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: Transmisor
    output_language: python
    title: Transmisor (AM o DSB-SC)
  states: {}

blocks:
- name: Amplitud_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: Amplitud_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: Freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Freq [MHz]
    start: '4'
    step: '0.1'
    stop: '200'
    value: '50'
    widget: counter
  states: {}
- name: Freq_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,2
    start: '1000'
    step: '100'
    stop: '10000'
    value: '1000'
  states: {}
- name: Freq_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,2
    start: '1000'
    step: '100'
    stop: '10000'
    value: '1700'
  states: {}
- name: IF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: RF_Gain
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,1,1,1
    label: RF Gain (13 dB)
    'true': '13'
    type: int
    value: 'False'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,1
    label: Mode
    label0: USB
    label1: LSB
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitud_2
    freq: Freq_2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitud_1
    freq: Freq_1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Real part
    type: float
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: mode
    target: mode
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: Freq*1e6
    gain0: RF_Gain
    if_gain0: IF_Gain
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: Freq
    fftsize: '1024'
    gui_hint: 3,0,3,4
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: LSB
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: USB
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: LSB
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: USB
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', hilbert_fc_0, '0']
- [blocks_conjugate_cc_0, '0', virtual_sink_0, '0']
- [blocks_selector_0, '0', blocks_throttle_0, '0']
- [blocks_selector_0, '0', osmosdr_sink_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_var_to_msg_0, msgout, blocks_selector_0, iindex]
- [hilbert_fc_0, '0', blocks_conjugate_cc_0, '0']
- [hilbert_fc_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', blocks_selector_0, '1']
- [virtual_source_0_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
