options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: Sweeper
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '435000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: int(freq)
    gain0: '0'
    if_gain0: '35'
    sample_rate: samp_rate/10
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=1
    bb_gain0: '20'
    freq0: '435000000'
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: sweeper_variable_sweeper_0
  id: sweeper_variable_sweeper
  parameters:
    dwell_time_ms: '3000'
    mode: PING_PONG
    start_value: '434000000'
    step_size: '50000'
    stop_value: '436000000'
    timing_mode: USE_STEP_SIZE
    update_rate_ms: '20'
  states: {}

connections:
- [analog_const_source_x_0, '0', osmosdr_sink_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [sweeper_variable_sweeper_0, out, blocks_msgpair_to_var_0, inpair]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
