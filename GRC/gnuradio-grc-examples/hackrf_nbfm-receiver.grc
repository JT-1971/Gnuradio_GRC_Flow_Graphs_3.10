options:
  parameters:
    author: ee
    description: rr
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: fm_helloworld
    output_language: python
    title: ww
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: bb_gain
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 4,0,1,5
    label: bbGain
    max: '50'
    min: '0'
    notebook: nbook,0
    num_steps: '50'
    style: wx.SL_HORIZONTAL
    value: '50'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: fm_low_pass_filter
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: int(samp_rate/quadrature)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: if_gain
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 1,6,1,5
    label: IF Gain
    max: '50'
    min: '0'
    notebook: nbook,0
    num_steps: '50'
    style: wx.SL_HORIZONTAL
    value: '30'
  states: {}
- name: nbook
  id: notebook
  parameters:
    grid_pos: 0,0,5,5
    labels: '[''Receiver'']'
    style: wx.NB_TOP
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '32'
    freq0: 435.1e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: resampler_toward_sink_rate
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature/1e3)
    interp: int(audio_rate/1e3)
    taps: ''
    type: fff
  states: {}
- name: rf_gain
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 3,0,1,6
    label: RF Gain
    max: '50'
    min: '0'
    notebook: nbook,0
    num_steps: '50'
    style: wx.SL_HORIZONTAL
    value: '20'
  states: {}
- name: rx_freq
  id: variable_static_text
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 0,0,1,1
    label: Receive
    notebook: nbook,0
    value: usrp_freq+xlate_tune
  states: {}
- name: transition_slider
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 3,6,1,5
    label: Low-Pass Transition (kHz)
    max: 1e3
    min: '1'
    notebook: nbook,0
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '50'
  states: {}
- name: usrp_freq
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 1,0,1,6
    label: USRP frequency
    max: 108e6
    min: 88e6
    notebook: nbook,0
    num_steps: '200'
    style: wx.SL_HORIZONTAL
    value: 94.7e6
  states: {}
- name: volume
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 2,6,1,5
    label: Volume
    max: '10'
    min: '0'
    notebook: nbook,0
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '1'
  states: {}
- name: volume_multiplier
  id: blocks_multiply_const_vxx
  parameters:
    const: '.5'
    type: float
  states: {}
- name: wbfm_analog_receiver
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    deemph_tau: '75e-6'
    quad_rate: quadrature
  states: {}
- name: xlate_tune
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 2,0,1,6
    label: Fine frequency
    max: 250e3
    min: '-250e3'
    notebook: nbook,0
    num_steps: '500'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {}

connections:
- [fm_low_pass_filter, '0', wbfm_analog_receiver, '0']
- [osmosdr_source_0, '0', fm_low_pass_filter, '0']
- [resampler_toward_sink_rate, '0', volume_multiplier, '0']
- [volume_multiplier, '0', audio_sink_0, '0']
- [volume_multiplier, '0', blocks_float_to_complex_0, '0']
- [wbfm_analog_receiver, '0', resampler_toward_sink_rate, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
