options:
  parameters:
    author: c5e3 Ghazanfar Ali
    description: http://blog.fusionimage.at/   ghazanfar.ali@live.com
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: multi_dongle_44
    output_language: python
    title: Multi HackRF 38 MHz
  states: {}

blocks:
- name: cent_freq
  id: variable_qtgui_range
  parameters:
    start: '25000000'
    step: '1'
    stop: '500000000'
    value: '104700000'
  states: {}
- name: cropBW
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '500000'
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '- (samp_rate / 2)+cropBW'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate * 2
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: (samp_rate / 2) -cropBW
    offset: '0'
    phase: '0'
    samp_rate: samp_rate * 2
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=44320f
    bb_gain0: '30'
    dc_offset_mode0: '2'
    freq0: cent_freq +((samp_rate)/2)-cropBW
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '31'
    dc_offset_mode0: '2'
    freq0: cent_freq-((samp_rate)/2)+cropBW
    gain0: '6.5'
    gain_mode0: 'False'
    if_gain0: '31'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [osmosdr_source_0, '0', rational_resampler_xxx_0_0, '0']
- [osmosdr_source_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_1, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
