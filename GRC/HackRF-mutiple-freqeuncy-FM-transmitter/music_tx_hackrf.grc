options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: music_tx_hackrf
    output_language: python
  states: {}

blocks:
- name: Kosaka_Honoka
  id: variable
  parameters:
    value: '1'
  states: {}
- name: Kosaka_Honoka
  id: variable_qtgui_chooser
  parameters:
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {state: disabled}
- name: Minami_Kotori
  id: variable
  parameters:
    value: '1'
  states: {}
- name: Minami_Kotori
  id: variable_qtgui_chooser
  parameters:
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {state: disabled}
- name: Sonoda_Umi
  id: variable
  parameters:
    value: '1'
  states: {}
- name: Sonoda_Umi
  id: variable_qtgui_chooser
  parameters:
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {state: disabled}
- name: hseconds
  id: variable
  parameters:
    value: '0'
  states: {}
- name: minutes
  id: variable
  parameters:
    value: '0'
  states: {}
- name: seconds
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_wfm_tx_1
  id: analog_wfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1.0'
    max_dev: 3e3
    quad_rate: '44100'
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: 1e6
    sample_rate: samp_rate*100
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    freq: '-1.5e6'
    sample_rate: samp_rate*100
  states: {}
- name: blocks_freqshift_cc_2
  id: blocks_freqshift_cc
  parameters:
    freq: '0.0'
    sample_rate: samp_rate*100
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: seconds
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: minutes
  states: {}
- name: blocks_msgpair_to_var_2
  id: blocks_msgpair_to_var
  parameters:
    target: hseconds
  states: {}
- name: blocks_msgpair_to_var_3
  id: blocks_msgpair_to_var
  parameters:
    target: Sonoda_Umi
  states: {}
- name: blocks_msgpair_to_var_3_0
  id: blocks_msgpair_to_var
  parameters:
    target: Kosaka_Honoka
  states: {}
- name: blocks_msgpair_to_var_3_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: Minami_Kotori
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Minami_Kotori
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Kosaka_Honoka
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: Sonoda_Umi
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: ''
    target: hseconds
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: ''
    target: hseconds
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: ''
    target: hseconds
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    repeat: 'False'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Timer',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.message_port_register_out(pmt.intern('minute'))\n        self.message_port_register_out(pmt.intern('second'))\n        self.message_port_register_out(pmt.intern('hsecond'))\n    def work(self,input_items, output_items):\n        start = time.time()\n        while (True):\n            elap = time.time() - start\n            minutes = int (elap / 60)\n            seconds = int (elap - minutes * 60)\n            hseconds = int((elap - minutes*60.0 - seconds) *100)\n            seconds_message = pmt.from_long (seconds)\n            minutes_message = pmt.from_long (minutes)\n            hseconds_message = pmt.from_long (hseconds)\n            self.message_port_pub(pmt.intern('hsecond'), pmt.cons(pmt.string_to_symbol(\"hseconds\"), hseconds_message))\n            self.message_port_pub(pmt.intern('second'),pmt.cons(pmt.string_to_symbol(\"seconds\"), seconds_message))\n            self.message_port_pub(pmt.intern('minute'), pmt.cons(pmt.string_to_symbol(\"minutes\"), minutes_message))\n            time.sleep(0.001)\n            \n"
    example_param: '1.0'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, hseconds = 0, seconds = 0, minutes = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Sonoda Umi',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_in(pmt.intern('hseconds'))
              self.message_port_register_out(pmt.intern('Sonoda_Umi'))
              self.set_msg_handler(pmt.intern('hseconds'),self.check)
              self.hseconds = hseconds
              self.seconds = seconds
              self.minutes = minutes
              
              
          def work(self, input_items, output_items):
              None
          def check(self, msg):
              hseconds = self.hseconds
              seconds = self.seconds
              minutes = self.minutes
              if minutes == 0 and seconds == 23 and hseconds == 30:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 0 and seconds == 36 and hseconds == 9:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 0 and seconds == 42 and hseconds == 7:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 0 and seconds == 51 and hseconds == 30:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 0 and seconds == 54 and hseconds == 59:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 1 and seconds == 1 and hseconds == 16:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 1 and seconds == 21 and hseconds == 72:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 1 and seconds == 23 and hseconds == 86:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 1 and seconds == 24 and hseconds == 18:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 1 and seconds == 25 and hseconds == 93:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 1 and seconds == 27 and hseconds == 11:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 1 and seconds == 27 and hseconds ==97:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 1 and seconds == 46 and hseconds == 32:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 1 and seconds == 49 and hseconds == 64:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 1 and seconds == 52 and hseconds == 63:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 1 and seconds == 55 and hseconds == 64:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 1 and seconds == 58 and hseconds == 93:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 2 and seconds == 1 and hseconds == 75:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 2 and seconds == 4 and hseconds == 98:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 2 and seconds == 11 and hseconds == 62:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 2 and seconds == 33 and hseconds == 24:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 2 and seconds == 34 and hseconds == 80:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 2 and seconds == 35 and hseconds == 38:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 2 and seconds == 37 and hseconds == 29:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 2 and seconds == 45 and hseconds == 40:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 2 and seconds == 54 and hseconds == 86: # 间奏
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 3 and seconds == 10 and hseconds == 71:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 3 and seconds == 13 and hseconds == 57:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 3 and seconds == 17 and hseconds == 7:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 3 and seconds == 23 and hseconds == 31:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 3 and seconds == 42 and hseconds == 34:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 3 and seconds == 44 and hseconds == 53: # tooi
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 3 and seconds == 45 and hseconds == 13: # yume no[Honoka]
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 3 and seconds == 46 and hseconds == 97: # dakedo
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
              if minutes == 3 and seconds == 47 and hseconds == 68:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(0)))
              if minutes == 3 and seconds == 49 and hseconds == 7:
                  self.message_port_pub(pmt.intern('Sonoda_Umi'),pmt.cons(pmt.string_to_symbol("Sonoda_Umi"), pmt.from_long(1)))
    hseconds: hseconds
    minutes: minutes
    seconds: seconds
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, hseconds = 0, seconds = 0, minutes = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Kosaka Honoka',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_in(pmt.intern('hseconds'))
              self.message_port_register_out(pmt.intern('Kosaka_Honoka'))
              self.set_msg_handler(pmt.intern('hseconds'),self.check)
              self.hseconds = hseconds
              self.seconds = seconds
              self.minutes = minutes
              
              
          def work(self, input_items, output_items):
              None
          def check(self, msg):
              hseconds = self.hseconds
              seconds = self.seconds
              minutes = self.minutes
              if minutes == 0 and seconds == 23 and hseconds == 30:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 0 and seconds == 42 and hseconds == 7:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 0 and seconds == 48 and hseconds == 60:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 0 and seconds == 54 and hseconds == 59:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 1 and seconds == 22 and hseconds == 87:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 1 and seconds == 24 and hseconds == 18:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 1 and seconds == 24 and hseconds == 99:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 1 and seconds == 27 and hseconds == 11:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 1 and seconds == 46 and hseconds == 32:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 1 and seconds == 52 and hseconds == 63:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 1 and seconds == 58 and hseconds == 93:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 2 and seconds == 4 and hseconds == 98:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 2 and seconds == 32 and hseconds == 7:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 2 and seconds == 33 and hseconds == 24:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 2 and seconds == 34 and hseconds == 35:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 2 and seconds == 35 and hseconds == 38:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 2 and seconds == 36 and hseconds == 30:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 2 and seconds == 38 and hseconds == 61:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 3 and seconds == 10 and hseconds == 71:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 3 and seconds == 17 and hseconds == 7:
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 3 and seconds == 43 and hseconds == 63: # Sore wa[Kotori]
                 self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 3 and seconds == 45 and hseconds == 13: # yume no
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1)))
              if minutes == 3 and seconds == 45 and hseconds == 57: # Kakera
                  self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(0)))
              if minutes == 3 and seconds == 47 and hseconds == 68:
                 self.message_port_pub(pmt.intern('Kosaka_Honoka'),pmt.cons(pmt.string_to_symbol("Kosaka_Honoka"), pmt.from_long(1))) 
    hseconds: hseconds
    minutes: minutes
    seconds: seconds
  states: {}
- name: epy_block_2_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, hseconds = 0, seconds = 0, minutes = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Minami Kotori',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_in(pmt.intern('hseconds'))
              self.message_port_register_out(pmt.intern('Minami_Kotori'))
              self.set_msg_handler(pmt.intern('hseconds'),self.check)
              self.hseconds = hseconds
              self.seconds = seconds
              self.minutes = minutes
              
              
          def work(self, input_items, output_items):
              None
          def check(self, msg):
              hseconds = self.hseconds
              seconds = self.seconds
              minutes = self.minutes
              if minutes == 0 and seconds == 36 and hseconds == 9:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 0 and seconds == 48 and hseconds == 60:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 0 and seconds == 51 and hseconds == 34:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 1 and seconds == 1 and hseconds == 16:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 1 and seconds == 21 and hseconds == 72:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 1 and seconds == 22 and hseconds == 87:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 1 and seconds == 23 and hseconds == 86:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 1 and seconds == 24 and hseconds == 99:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 1 and seconds == 25 and hseconds == 93:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 1 and seconds == 27 and hseconds == 97:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 1 and seconds == 49 and hseconds == 64:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 1 and seconds == 55 and hseconds == 64:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 2 and seconds == 1 and hseconds == 75:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 2 and seconds == 11 and hseconds == 62:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 2 and seconds == 32 and hseconds ==7:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 2 and seconds == 34 and hseconds == 35:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 2 and seconds == 34 and hseconds == 80:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 2 and seconds == 36 and hseconds == 30:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 2 and seconds == 37 and hseconds == 29:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 2 and seconds == 38 and hseconds == 61:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 2 and seconds == 45 and hseconds == 40: 
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 2 and seconds == 54 and hseconds == 86: # 间奏
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 3 and seconds == 13 and hseconds == 57:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 3 and seconds == 23 and hseconds == 31:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 3 and seconds == 42 and hseconds == 34:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 3 and seconds == 43 and hseconds == 63:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 3 and seconds == 44 and hseconds == 53: # tooi[Umi]
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 3 and seconds == 45 and hseconds == 57: # kakera
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
              if minutes == 3 and seconds == 46 and hseconds == 97: # Dakedo
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(0)))
              if minutes == 3 and seconds == 49 and hseconds == 7:
                  self.message_port_pub(pmt.intern('Minami_Kotori'),pmt.cons(pmt.string_to_symbol("Minami_Kotori"), pmt.from_long(1)))
    hseconds: hseconds
    minutes: minutes
    seconds: seconds
  states: {}
- name: freq
  id: parameter
  parameters:
    short_id: f
    type: eng_float
    value: 146e6
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: 146e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate*100
    sync: none
    type: fc32
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: ppm
    short_id: p
    type: eng_float
    value: '0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: 44.1e3
  states: {}

connections:
- [analog_wfm_tx_1, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', analog_wfm_tx_1, '0']
- [blocks_add_xx_1, '0', osmosdr_sink_0, '0']
- [blocks_add_xx_1, '0', qtgui_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_freqshift_cc_1, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_freqshift_cc_2, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_1, '2']
- [blocks_null_source_0, '0', epy_block_0, '0']
- [blocks_var_to_msg_0, msgout, epy_block_2, hseconds]
- [blocks_var_to_msg_0_0, msgout, epy_block_2_0, hseconds]
- [blocks_var_to_msg_0_0_0, msgout, epy_block_2_0_0, hseconds]
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [epy_block_0, hsecond, blocks_msgpair_to_var_2, inpair]
- [epy_block_0, minute, blocks_msgpair_to_var_1, inpair]
- [epy_block_0, second, blocks_msgpair_to_var_0, inpair]
- [epy_block_2, Sonoda_Umi, blocks_msgpair_to_var_3, inpair]
- [epy_block_2_0, Kosaka_Honoka, blocks_msgpair_to_var_3_0, inpair]
- [epy_block_2_0_0, Minami_Kotori, blocks_msgpair_to_var_3_0_0, inpair]
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_1, '0']
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_2, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
