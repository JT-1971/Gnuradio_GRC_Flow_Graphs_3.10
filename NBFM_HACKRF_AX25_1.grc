options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: Specan
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_offset
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '100'
    step: '.001'
    stop: '450'
    value: '145.175'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '7500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: '"Squelch"'
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: APRS_Rx_0
  id: APRS_Rx
  parameters:
    baud: '1200'
    gmu: '0.175'
    mark: '1200'
    mu: '0.5'
    samp_rate: 48e3
    space: '2400'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: fsk_deviation_hz
    quad_rate: '480000'
    tau: '50e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: '-squelch'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: display_text_msg_0
  id: display_text_msg
  parameters:
    label: ' ""'
    maxlines: '100'
    messagekey: ''
    splitlength: '1000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport os, pty\nimport struct\n\nimport pmt\nimport numpy as np\nfrom gnuradio import gr\n\nimport packet\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    Converts an array of bytes into a AX25Packet object.\n\n    Connect to the \"HDLC Deframer\", or a block which emits a PMT tuple of\n    (None, bytearray)\n    \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,\n                               name=\"HDLC to AX.25\",\n                               in_sig=None,\n                               out_sig=None)\n        self.message_port_register_in(pmt.intern('hdlc in'))\n        self.message_port_register_out(pmt.intern('ax25 out'))\n        self.set_msg_handler(pmt.intern('hdlc in'), self.handle_msg)\n\n    def handle_msg(self, msg_pmt):\n        msg_pmt = pmt.pmt_to_python.pmt_to_python(msg_pmt)\n\n        msg = bytearray(msg_pmt[1])\n\n        try:\n            pkt = packet.from_bytes(msg)\n            self.message_port_pub(pmt.intern('ax25 out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(np.array([ord(c) for c in (packet.dump(pkt) + '\\n')], np.uint8))))\n                \n        except ValueError as e:\n            print(e)\n\n    def stop(self):\n        gr.sync_block.stop(self)\n        \n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        # <+signal processing here+>\n        return len(input_items[0])\n        \n        \n        \n"
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '192000'
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '5000'
    win: '2'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '24'
    freq0: (frequency*1e6)+freq_offset
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    fc: frequency*1e6
    fftsize: '2048'
    name: Quadrature Baseband
    norm_window: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: '2048'
    srate: '192000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [APRS_Rx_0, HDLC, epy_block_0, hdlc in]
- [analog_nbfm_rx_0, '0', APRS_Rx_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', filter_fft_low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [epy_block_0, ax25 out, display_text_msg_0, text]
- [filter_fft_low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_correctiq_0, '0']
- [filter_fft_low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
