options:
  parameters:
    generate_options: qt_gui
    id: epic
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: AGC_set
  id: variable_qtgui_range
  parameters:
    label: AGC_set
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.2'
  states: {}
- name: Avg_count
  id: variable_qtgui_range
  parameters:
    label: Avg_count
    start: '1'
    step: '1'
    stop: '12'
    value: '4'
  states: {}
- name: CFAR_exclution_bins
  id: variable_qtgui_range
  parameters:
    label: CFAR_exclution_bins
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {state: disabled}
- name: CFAR_gaurd_cells
  id: variable_qtgui_range
  parameters:
    label: CFAR_gaurd_cells
    start: '0'
    step: '1'
    stop: '10'
    value: '8'
  states: {state: disabled}
- name: CFAR_threshold
  id: variable_qtgui_range
  parameters:
    label: CFAR_threshold
    start: '-200'
    step: '1'
    stop: '100'
    value: '-10'
  states: {state: disabled}
- name: CFAR_training_cells
  id: variable_qtgui_range
  parameters:
    label: CFAR_training_cells
    start: '0'
    step: '1'
    stop: '10'
    value: '8'
  states: {state: disabled}
- name: CFAR_velocity_threshold
  id: variable_qtgui_range
  parameters:
    label: CFAR_velocity_threshold
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {state: disabled}
- name: FFT
  id: variable
  parameters:
    value: 1024*12
  states: {}
- name: Gamma
  id: variable_qtgui_range
  parameters:
    label: Gamma
    start: '0'
    step: '0.1'
    stop: '10'
    value: '2.2'
  states: {}
- name: Min_display_db
  id: variable_qtgui_range
  parameters:
    label: Min_display_db
    start: '-200'
    step: '10'
    stop: '20'
    value: '-40'
  states: {}
- name: TGC_factor
  id: variable_qtgui_range
  parameters:
    label: TGC_factor
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: bandwidth
    start: 100e6
    step: 100e4
    stop: 1000e6
    value: 800e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 5.4e9
  states: {}
- name: chrip_rate
  id: variable_qtgui_range
  parameters:
    label: chrip_rate
    start: '100'
    step: '100'
    stop: '4000'
    value: '500'
  states: {}
- name: chrips_per_batch
  id: variable
  parameters:
    value: '64'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: delay
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {state: disabled}
- name: detection_threshold
  id: variable_qtgui_range
  parameters:
    label: detection_threshold
    start: '0.1'
    step: '0.05'
    stop: '1'
    value: '0.5'
  states: {}
- name: max_display_db
  id: variable_qtgui_range
  parameters:
    label: max_display_db
    start: '-100'
    step: '10'
    stop: '100'
    value: '50'
  states: {}
- name: range_cal
  id: variable_qtgui_range
  parameters:
    label: range_cal
    start: '0'
    step: '1'
    stop: '500'
    value: '10'
  states: {state: disabled}
- name: range_gate_max
  id: variable_qtgui_range
  parameters:
    label: range_gate_max
    start: '0'
    step: '1'
    stop: '500'
    value: '20'
  states: {}
- name: range_gate_min
  id: variable_qtgui_range
  parameters:
    label: range_gate_min
    start: '0'
    step: '1'
    stop: '200'
    value: '4'
  states: {}
- name: range_per_batch
  id: variable_qtgui_range
  parameters:
    label: range_per_batch
    start: '16'
    step: '1'
    stop: '512'
    value: '128'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: x_axis_max
  id: variable_qtgui_range
  parameters:
    label: x_axis_max
    start: '0'
    step: '1'
    stop: '500'
    value: '20'
  states: {}
- name: x_axis_min
  id: variable_qtgui_range
  parameters:
    label: x_axis_min
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: y_axis_max
  id: variable_qtgui_range
  parameters:
    label: y_axis_max
    start: '0'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: y_axis_min
  id: variable_qtgui_range
  parameters:
    label: y_axis_min
    start: '-20'
    step: '1'
    stop: '0'
    value: '-10'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    minoutbuf: '1024'
    num_outputs: '2'
    samp_rate: '192000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: FFT
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '960'
    type: float
  states: {state: disabled}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '960'
    type: complex
  states: {state: disabled}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: '10000'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    maxoutbuf: '1024'
    minoutbuf: '1'
    num_items: '1024'
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: FFT
    type: complex
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: FFT
    type: float
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          measure_chirp_freq:
            A simple example block that:
             - Takes a single float input (sync pulse).
             - Detects rising edges above a threshold.
             - For each edge after the first, compute the chirp frequency in Hz
               = fs / (edge_index - last_edge_index), where fs is sample_rate.
             - Output that frequency as a float.
               We produce the same freq value for all samples from this edge
               until the next edge is found, for demonstration purposes.
          """

          def __init__(self, threshold=0.5, sample_rate=96000.0):
              """
              threshold: amplitude threshold for rising-edge detection
              sample_rate: the sampling rate of the incoming stream
              """
              gr.sync_block.__init__(
                  name='measure_chirp_freq',
                  in_sig=[np.float32],   # 1 float input
                  out_sig=[np.float32]   # 1 float output
              )
              self.threshold = threshold
              self.sample_rate = sample_rate

              # We store the "running" sample index across multiple work() calls
              self.running_index = 0
              # The index of the last rising edge (None if we haven't found one yet)
              self.last_edge_index = None
              # The frequency we most recently computed
              self.current_freq = 0.0

          def work(self, input_items, output_items):
              in0 = input_items[0]   # shape: (n,) 
              out0 = output_items[0] # shape: (n,)

              n = len(in0)
              # Convert to 0 or 1 by threshold
              bin_sync = (in0 > self.threshold).astype(np.int8)
              # find rising edges
              diff = np.diff(bin_sync)
              edge_indices = np.where(diff == 1)[0] + 1  # local indices in [0..n-1]

              out_idx = 0  # how many samples of out we produce
              # We'll produce an output for each sample, 
              # but the freq value is constant between edges.

              for i in range(n):
                  # check if i is in the edge_indices
                  # better approach: if i in edge_indices:
                  # but that is O(n * #edges). We'll do a simpler approach:
                  # Actually, let's just see if i is an edge in a dictionary
                  # but to keep it short, we'll scan edge_indices
                  # (This is not the most efficient, but it's simpler to read.)
                  if i in edge_indices:
                      # Global index of this edge
                      global_edge_idx = self.running_index + i
                      if self.last_edge_index is not None:
                          delta_samples = global_edge_idx - self.last_edge_index
                          # compute freq in Hz
                          if delta_samples > 0:
                              self.current_freq = self.sample_rate / float(delta_samples)
                      # update last edge
                      self.last_edge_index = global_edge_idx

                  # produce the current_freq
                  out0[out_idx] = self.current_freq
                  out_idx += 1

              # we've used n input samples, produced n output samples
              self.running_index += n
              self.consume_each(n)
              return n
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    TGC_enabled: 'True'
    TGC_factor: TGC_factor
    _source_code: |
      import numpy as np
      import matplotlib.pyplot as plt
      from gnuradio import gr

      class fmcw_chirp_processor(gr.sync_block):
          """
          GNU Radio Embedded Python Block for Real-Time FMCW Radar Processing.

          This version has been cleaned up to remove unused parameters (decimation, bandwidth,
          fft_intensity, max_range, hilbert). In addition, it implements Time Gain Compensation (TGC)
          in the range domain: returns from farther ranges are amplified more.
          
          Retained features include:
            - AGC (auto gain control),
            - Pre-FFT windowing (hann/hamming/blackman/none),
            - MTI filtering (modes: "off", "single", "double"),
            - Coherent averaging,
            - Range gating via range_gate_start_m and range_gate_stop_m,
            - Manual axis calibration (x_axis_min/x_axis_max and y_axis_min/y_axis_max).

          New TGC parameters:
            - TGC_enabled (bool): enable TGC if True.
            - TGC_factor (float, 1/m): linear gain factor; gain(r) = 1 + TGC_factor * r.
          """
          
          def __init__(self,
                       samp_rate=192e3,
                       chirp_rate=400.0,
                       threshold=0.5,
                       chirps_per_batch=16,
                       fft_size=0,
                       mti_mode="single",          # Options: "off", "single", "double"
                       coherent_avg_count=1,
                       range_gate_start_m=0.0,
                       range_gate_stop_m=0.0,
                       min_display_db=-60.0,
                       max_display_db=20.0,
                       agc_enabled=True,
                       agc_target=0.5,
                       window_type="hann",         # Options: "hann", "hamming", "blackman", "none"
                       gamma=1.0,
                       # Manual axis calibration:
                       x_axis_min=0.0,
                       x_axis_max=10.0,
                       y_axis_min=0.0,
                       y_axis_max=64.0,
                       # New TGC parameters:
                       TGC_enabled=True,
                       TGC_factor=0.001):
              gr.sync_block.__init__(
                  self,
                  name="FMCW Chirp Processor",
                  in_sig=[np.float32, np.float32],
                  out_sig=None
              )
              # Save parameters
              self.samp_rate = samp_rate
              self.chirp_rate = chirp_rate
              self.threshold = threshold
              self.chirps_per_batch = int(chirps_per_batch)
              self.fft_size = int(fft_size) if fft_size > 0 else 0
              self.mti_mode = mti_mode.lower().strip()
              self.coherent_avg_count = int(coherent_avg_count)
              self.range_gate_start_m = range_gate_start_m
              self.range_gate_stop_m = range_gate_stop_m
              self.min_display_db = min_display_db
              self.max_display_db = max_display_db
              self.agc_enabled = agc_enabled
              self.agc_target = agc_target
              self.window_type = window_type.lower().strip()
              self.gamma = gamma
              
              # Manual axis calibration
              self.x_axis_min = x_axis_min
              self.x_axis_max = x_axis_max
              self.y_axis_min = y_axis_min
              self.y_axis_max = y_axis_max
              
              # Fixed internal parameter for bandwidth (not user‑adjustable)
              self.bandwidth = 200e6
              # Derived radar parameters
              self.chirp_duration = 1.0 / self.chirp_rate
              self.slope = self.bandwidth / self.chirp_duration  # Hz/s
              self.c = 3e8  # speed of light
              
              # TGC parameters
              self.TGC_enabled = TGC_enabled
              self.TGC_factor = TGC_factor
              
              # Internal state
              self.prev_sync = None
              self.current_chirp = []
              self.chirps_buffer = []
              self.coherent_sum = None
              self.avg_count = 0
              
              # Setup plotting
              plt.ion()
              self.fig, self.ax = plt.subplots()
              self.img = None
              self.ax.set_title("Range-Doppler Map")
              self.ax.set_xlabel("Range (m)")
              self.ax.set_ylabel("Doppler Bin")
              self.fig.show()
              
          def _apply_mti(self, matrix):
              """
              Apply MTI filtering along the chirp dimension (axis=0).
              Modes:
                - "off": no filtering,
                - "single": x[n] - x[n-1],
                - "double": x[n] - 2*x[n-1] + x[n-2].
              """
              if matrix.shape[0] < 2:
                  return matrix
              
              if self.mti_mode == "off":
                  return matrix
              elif self.mti_mode == "single":
                  return np.diff(matrix, axis=0)
              elif self.mti_mode == "double":
                  if matrix.shape[0] < 3:
                      return np.diff(matrix, axis=0)
                  return matrix[2:] - 2 * matrix[1:-1] + matrix[:-2]
              else:
                  return matrix
              
          def work(self, input_items, output_items):
              sync_signal = input_items[0]
              radar_signal = input_items[1]
              n = len(sync_signal)
              if n == 0:
                  return 0
              
              # Detect chirp boundaries based on sync ramp
              if self.prev_sync is not None:
                  if sync_signal[0] < self.threshold and self.prev_sync >= self.threshold:
                      if self.current_chirp:
                          chirp_array = np.array(self.current_chirp, dtype=np.float32)
                          self.chirps_buffer.append(chirp_array)
                      self.current_chirp = []
              
              last_sync = self.prev_sync if self.prev_sync is not None else sync_signal[0]
              for i in range(n):
                  s_val = sync_signal[i]
                  r_val = radar_signal[i]
                  if s_val < self.threshold and last_sync >= self.threshold:
                      if self.current_chirp:
                          chirp_array = np.array(self.current_chirp, dtype=np.float32)
                          self.chirps_buffer.append(chirp_array)
                      self.current_chirp = [r_val]
                  else:
                      self.current_chirp.append(r_val)
                  last_sync = s_val
              
              self.prev_sync = last_sync
              
              if len(self.chirps_buffer) >= self.chirps_per_batch:
                  batch_size = self.chirps_per_batch
                  chirp_batch = self.chirps_buffer[:batch_size]
                  self.chirps_buffer = self.chirps_buffer[batch_size:]
                  
                  # Align chirps to same length
                  min_len = min(len(chirp) for chirp in chirp_batch)
                  fft_len = self.fft_size if (self.fft_size and self.fft_size > min_len) else min_len
                  
                  range_fft_list = []
                  for chirp in chirp_batch:
                      x = chirp[:min_len]
                      if self.agc_enabled:
                          rms = np.sqrt(np.mean(x**2))
                          gain = self.agc_target / (rms + 1e-6)
                          x = x * gain
                      if self.window_type != "none":
                          if self.window_type == "hann":
                              w = np.hanning(len(x))
                          elif self.window_type == "hamming":
                              w = np.hamming(len(x))
                          elif self.window_type == "blackman":
                              w = np.blackman(len(x))
                          else:
                              w = np.ones(len(x))
                          x = x * w
                      if fft_len > len(x):
                          x = np.pad(x, (0, fft_len - len(x)), 'constant')
                      else:
                          x = x[:fft_len]
                      spectrum = np.fft.fft(x)
                      range_fft_list.append(spectrum)
                  
                  range_fft_matrix = np.vstack(range_fft_list)
                  range_fft_matrix = self._apply_mti(range_fft_matrix)
                  if range_fft_matrix.shape[0] == 0:
                      return n
                  
                  doppler_matrix = np.fft.fft(range_fft_matrix, axis=0)
                  doppler_matrix = np.fft.fftshift(doppler_matrix, axes=0)
                  
                  if self.coherent_avg_count > 1:
                      if self.coherent_sum is None:
                          self.coherent_sum = doppler_matrix.copy()
                      else:
                          self.coherent_sum += doppler_matrix
                      self.avg_count += 1
                      if self.avg_count < self.coherent_avg_count:
                          return n
                      else:
                          doppler_matrix = self.coherent_sum / float(self.avg_count)
                          self.coherent_sum = None
                          self.avg_count = 0
                  
                  # Compute magnitude before gamma correction
                  magnitude = np.abs(doppler_matrix)
                  
                  # Compute range axis from FFT frequency bins (using full sample rate)
                  fft_len_out = magnitude.shape[1]
                  freq_bins_full = np.fft.fftfreq(fft_len_out, d=1.0/self.samp_rate)
                  pos_mask = (freq_bins_full >= 0)
                  freq_bins = freq_bins_full[pos_mask]
                  range_axis_full = freq_bins * self.c / (2.0 * self.slope)
                  # Apply TGC: Multiply each range bin by a gain factor that increases with range
                  if self.TGC_enabled:
                      # Linear TGC: gain(r) = 1 + TGC_factor * r
                      gain_curve = 1.0 + self.TGC_factor * range_axis_full
                      magnitude = magnitude[:, pos_mask] * gain_curve[np.newaxis, :]
                  else:
                      magnitude = magnitude[:, pos_mask]
                  
                  # Optional gamma correction
                  if self.gamma != 1.0:
                      norm = magnitude / (np.max(magnitude) + 1e-6)
                      magnitude = norm ** self.gamma * (np.max(magnitude) + 1e-6)
                  rd_map = 20 * np.log10(magnitude + 1e-6)
                  
                  # Optionally apply range gating
                  if self.range_gate_stop_m > self.range_gate_start_m:
                      start_idx = np.searchsorted(range_axis_full, self.range_gate_start_m, side='left')
                      stop_idx = np.searchsorted(range_axis_full, self.range_gate_stop_m, side='right')
                      start_idx = max(0, start_idx)
                      stop_idx = min(len(range_axis_full), stop_idx)
                      rd_map = rd_map[:, start_idx:stop_idx]
                      range_axis = range_axis_full[start_idx:stop_idx]
                  else:
                      range_axis = range_axis_full
                  
                  ny = rd_map.shape[0]
                  nx = rd_map.shape[1]
                  if nx == 0:
                      return n
                  
                  # Use manual axis extents for display (manual calibration)
                  extent = [self.x_axis_min, self.x_axis_max, self.y_axis_min, self.y_axis_max]
                  
                  if self.img is None:
                      self.img = self.ax.imshow(rd_map,
                                                aspect='auto',
                                                origin='lower',
                                                extent=extent,
                                                vmin=self.min_display_db,
                                                vmax=self.max_display_db,
                                                interpolation='nearest')
                      self.ax.set_xlabel("Range (m)")
                      self.ax.set_ylabel("Doppler Bin")
                      self.fig.colorbar(self.img, ax=self.ax, label="Magnitude (dB)")
                  else:
                      self.img.set_data(rd_map)
                      self.img.set_extent(extent)
                      self.img.set_clim(self.min_display_db, self.max_display_db)
                  
                  self.fig.canvas.draw()
                  self.fig.canvas.flush_events()
              
              return n
    agc_enabled: 'True'
    agc_target: AGC_set
    chirp_rate: chrip_rate
    chirps_per_batch: chrips_per_batch
    coherent_avg_count: Avg_count
    fft_size: FFT
    gamma: Gamma
    max_display_db: max_display_db
    min_display_db: Min_display_db
    mti_mode: '"off"'
    range_gate_start_m: range_gate_min
    range_gate_stop_m: range_gate_max
    samp_rate: samp_rate
    threshold: detection_threshold
    window_type: '"hamming"'
    x_axis_max: x_axis_max
    x_axis_min: x_axis_min
    y_axis_max: y_axis_max
    y_axis_min: y_axis_min
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: FFT
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(FFT)
  states: {state: disabled}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: window.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    type: float
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: 256*4
    nrows: 256*4
    samp_rate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: 1024*2
    srate: samp_rate
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: 5.4e9
    freq_sweep: '10000000'
    len_key: '"packet_len"'
    samp_cw: '0'
    samp_down: '0'
    samp_rate: '20000000'
    samp_up: '100000'
  states: {state: disabled}
- name: radar_signal_generator_fsk_c_0
  id: radar_signal_generator_fsk_c
  parameters:
    len_key: '"packet_len"'
  states: {state: disabled}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_moving_average_xx_0, '0']
- [analog_agc_xx_0, '0', low_pass_filter_1, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_1, '0']
- [audio_source_0, '0', epy_block_1, '1']
- [audio_source_0, '0', low_pass_filter_0, '0']
- [audio_source_0, '0', low_pass_filter_1, '0']
- [audio_source_0, '0', low_pass_filter_2, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '1']
- [audio_source_0, '1', epy_block_1, '0']
- [audio_source_0, '1', low_pass_filter_2_0, '0']
- [audio_source_0, '1', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_sink_x_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_vector_to_stream_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', blocks_sub_xx_1, '1']
- [blocks_delay_1, '0', blocks_sub_xx_2, '1']
- [blocks_delay_2, '0', qtgui_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_delay_0, '0']
- [blocks_float_to_complex_0, '0', blocks_sub_xx_0, '0']
- [blocks_float_to_complex_0, '0', high_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_1, '0', blocks_delay_1, '0']
- [blocks_float_to_complex_1, '0', blocks_sub_xx_2, '0']
- [blocks_float_to_complex_1, '0', qtgui_sink_x_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_complex_to_mag_squared_1, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_sub_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_sub_xx_1, '0', audio_sink_0, '0']
- [blocks_sub_xx_1, '0', low_pass_filter_1, '0']
- [blocks_sub_xx_1, '0', qtgui_sink_x_0, '0']
- [blocks_sub_xx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_2, '0', qtgui_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [high_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [high_pass_filter_0, '0', blocks_delay_0, '0']
- [high_pass_filter_0, '0', blocks_sub_xx_0, '0']
- [high_pass_filter_0, '0', qtgui_histogram_sink_x_0, '0']
- [high_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [high_pass_filter_0, '0', qtgui_time_raster_sink_x_0, '0']
- [high_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_mag_squared_0, '0']
- [hilbert_fc_0, '0', blocks_delay_2, '0']
- [hilbert_fc_0, '0', blocks_stream_to_vector_1, '0']
- [hilbert_fc_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_sub_xx_1, '0']
- [low_pass_filter_0, '0', high_pass_filter_0, '0']
- [low_pass_filter_0, '0', hilbert_fc_0, '0']
- [low_pass_filter_1, '0', blocks_stream_to_vector_0, '0']
- [low_pass_filter_1, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_1, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_2, '0', epy_block_1, '1']
- [low_pass_filter_2_0, '0', epy_block_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
