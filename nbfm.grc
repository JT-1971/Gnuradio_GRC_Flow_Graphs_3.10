options:
  parameters:
    author: dakshinakali
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: NBFM_Rx
    output_language: python
    title: NBFM Rx
  states: {}

blocks:
- name: bbg
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: BB Gain
    start: '0'
    step: '2'
    stop: '62'
    value: '32'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: freq+500e3
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,1,1,1
    label: FREQ
    type: real
    value: 433e6
  states: {}
- name: ifg
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: IF Gain
    start: '0'
    step: '5'
    stop: '40'
    value: '32'
  states: {}
- name: nbfm_bandwidth
  id: variable
  parameters:
    value: 12e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: sql
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,1,1,1
    label: Squelch
    start: '-80'
    step: '1'
    stop: '80'
    value: '42'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,1,1,1
    label: Vol
    start: '0'
    step: '1'
    stop: '20'
    value: '8'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '100e-6'
    gain: '1'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 7.5e3
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '75e-6'
    gate: 'True'
    ramp: '10'
    threshold: sql
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq-freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: '30'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: nbfm_bandwidth
    decim: int(samp_rate/nbfm_bandwidth)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: bbg
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: ifg
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 0,1,1,1
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_agc3_xx_0, '0', low_pass_filter_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_agc3_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_moving_average_xx_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_1, '0']
- [rational_resampler_xxx_1, '0', analog_nbfm_rx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
