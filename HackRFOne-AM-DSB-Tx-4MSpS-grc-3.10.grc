options:
  parameters:
    author: Marcelo Doallo
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: Transmisor
    output_language: python
    title: Transmisor (AM o DSB-SC)
  states: {}

blocks:
- name: Amplitud
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,4
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: Amplitud_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: Amplitud_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: Freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Freq [MHz]
    start: '4'
    step: '0.1'
    stop: '200'
    value: '128.4'
    widget: counter
  states: {}
- name: Freq_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,2
    start: '1000'
    step: '100'
    stop: '10000'
    value: '1000'
  states: {}
- name: Freq_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,2
    start: '1000'
    step: '100'
    stop: '10000'
    value: '1700'
  states: {}
- name: IF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: RF_Gain
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,3,1,1
    label: RF Gain (13 dB)
    'true': '13'
    type: int
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: Amplitud
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitud_2
    freq: Freq_2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitud_1
    freq: Freq_1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Real part
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Complex envelope
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    comment: Imaginary part
    type: float
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    freq0: Freq*1e6
    gain0: RF_Gain
    if_gain0: IF_Gain
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4000000'
    type: ccc
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '0']
- [audio_source_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
