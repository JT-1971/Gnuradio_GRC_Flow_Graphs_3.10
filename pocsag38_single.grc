options:
  parameters:
    generate_options: qt_gui
    id: pocsag
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 22050*64
    value: 22050*64
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: samp_rate/8
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '8000'
    interp: '1'
    low_cutoff_freq: '50'
    samp_rate: samp_rate/64
    type: interp_fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      multimon-ng assumes 22050 Hz, 
      16-bit signed stream

      multimon-ng -t raw -c -a SCOPE -a POCSAG512 \
      -a POCSAG1200 -a POCSAG2400 /tmp/1
    file: /tmp/1
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 300e3
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '20000'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 466.015e6
    gain0: '42'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_wfm_rcv_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_float_to_short_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
